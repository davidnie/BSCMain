# Keil uVision project Pro.uvproj, settings and files
target Pro (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Pro +hex
  AfterMake: D:\Keil_v5\ARM\BIN40\fromelf.exe --bin --output ./BIN/pro.bin ./Debug/pro.axf
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4
  c include: ..\App;..\BSP;..\Module;..\CMSIS\Core;..\CMSIS\Driver;..\UCOS\Source;..\UCOS\Port;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\Utilities\Third_Party\lwip_v1.3.2\src\api;..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\netif\ppp;..\CMSIS\STM32F4x7_ETH_Driver\inc;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\arch;..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\src;..\inc;..\modbus\include;..\modbus\port;..\modbus\tcp;..\colib\inc;..\codrv\generic;..\colib\src;..\colib\energybus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: Main.c Task_Test.c appBMU.c Task_CAN1.c Task_CAN2.c Task_ADC.c Task_AVChg.c Task_EFlash.c appConfig.c Task_main.c Task_SysCheck.c Task_Wifi.c battery.c mesa.c
  group BSP
    ../BSP/: Bsp_Global.c NVIC.C stm32f4x7_eth_bsp.c netconf.c stm32f4xx_it.c httpd.c 24C02.c BSP_GPIO.c bsp_CAN.C BSP_ADC.c BSP_SCI.c DMA.C FlashDriver.c SST25VF016B.c BSP_WDG.c BSP_wifi.c HAL.c
  group Module
    ../Module/: M_Delay_P.c
  group CMSIS/Driver
    ../CMSIS/Driver/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group CMSIS/Core
    ../CMSIS/Core/: startup_stm32f4xx.s system_stm32f4xx.c arm_cortexM4lf_math.lib
  group UCOS/Port
    ../UCOS/Port/: app_cfg.h os_cfg.h os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c ucosii_inc.h
  group UCOS/Source
    ../UCOS/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group LWIP
    ../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F4x7_ETH_Driver
    ../CMSIS/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group src
    ../src/: SysTick.C timer.C pageMake.c shed_ctrl.c BMU_GT.c
    ../CANOpen/: GlobalVar.c
  group MODBUS
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/port/: portevent.c portserial.c porttimer.c porttcp.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/: mb.c mbtcp_task.c
  group CO_Slave
    ../colib/src/: co_candebug.c co_cobhandler.c co_commtask.c co_dynod.c co_emcy.c co_errctrl.c co_event.c co_led.c co_lss.c co_lssmaster.c co_nmt.c co_nmtmaster.c co_nmtslave.c co_odaccess.c co_pdo.c co_queue.c co_sdoclient.c co_sdoqueue.c co_sdoserv.c co_sleep.c co_stackinit.c co_store.c co_sync.c co_time.c co_timer.c co_user.c
    ../codrv/generic/: codrv_can_generic.c codrv_canbittiming.c codrv_cpu_generic.c codrv_error.c
    ../codrv/common/: can_printf.c
  group CO_EB
    ../colib/energybus/: eb_battery.c eb_debug.c eb_eeprom.c eb_framework.c eb_indication.c eb_state.c gen_objdict.c usr_ind.c
